# Keil uVision project supiri_9v_7s.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L053C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: supiri_9v_7s +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS\Include;.\config\inc;.\hw\inc;..\SUPIRI-9V-7S;.\CMSIS\Device\ST\STM32L0xx\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group app
    ./app/src/: main.c
  group hw
    ./hw/src/: adc.c btn.c button.c gpio.c hw.c i2c.c interrupt.c led.c nxp_lcd_driver.c rtc.c selenoid.c systick.c
  group startup
    ./hw/src/: startup_stm32l053xx.s system_stm32l0xx.c
